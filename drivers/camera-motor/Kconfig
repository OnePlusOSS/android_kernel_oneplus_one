## drivers/camera-motor/Kconfig
```kconfig
config CAMERA_MOTOR
	tristate "CAMERA MOTOR Controler"
	default n
	help
	  Say Y here to enable camera motor. 
```
